# Keil uVision project Wiznet.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051 Core CAST, Inc.
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: Wiznet
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil_v5\C51\INC\SiLABS;..\DDS_Projects\Wiznet w5500\Ethernet;..\Wiznet_new
  group Source Group 1
    ./: main.c My_fnc.c
